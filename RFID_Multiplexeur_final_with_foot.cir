.title KiCad schematic
U20 SDA16 SDA15 SDA14 SDA13 SDA12 SDA11 SDA10 SDA9 SDA8 SDA7 SDA6 SDA5 SDA4 SDA3 SDA2 SDA1 GND +3V3 GND MUX0 MUX1 MUX2 MUX3 SDA HW-178
U10 +5V NC_01 NC_02 NC_03 MUX1 NC_04 MUX0 MUX2 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 GND MOSI RST NC_16 NC_17 SDA NC_18 MISO SCK NC_19 DIn NC_20 BatLevel NC_21 NC_22 MUX3 NC_23 NC_24 NC_25 ESP32_DEV_KIT
J60 GND +5V Conn_01x02_Male
C10 +5V GND C
C40 +3V3 GND C
C41 +5V GND C
C51 +3V3 GND C
C20 +3V3 GND C
C71 +5V GND C
J70 +5V GND DIn Conn_01x03_Male
R37 +3V3 SDA11 R
R38 +3V3 SDA10 R
R35 +3V3 SDA13 R
R36 +3V3 SDA12 R
R33 +3V3 SDA15 R
R34 +3V3 SDA14 R
R32 +3V3 SDA16 R
R1 +3V3 SDA9 R
R8 +3V3 SDA2 R
R9 +3V3 SDA1 R
R6 +3V3 SDA4 R
R7 +3V3 SDA3 R
R4 +3V3 SDA6 R
R5 +3V3 SDA5 R
R2 +3V3 SDA8 R
R3 +3V3 SDA7 R
U1 +3V3 RST GND NC_26 MISO MOSI SCK SDA1 RF_RFID_RC522
U2 +3V3 RST GND NC_27 MISO MOSI SCK SDA2 RF_RFID_RC522
U3 +3V3 RST GND NC_28 MISO MOSI SCK SDA3 RF_RFID_RC522
U4 +3V3 RST GND NC_29 MISO MOSI SCK SDA4 RF_RFID_RC522
U5 +3V3 RST GND NC_30 MISO MOSI SCK SDA5 RF_RFID_RC522
U6 +3V3 RST GND NC_31 MISO MOSI SCK SDA6 RF_RFID_RC522
U7 +3V3 RST GND NC_32 MISO MOSI SCK SDA7 RF_RFID_RC522
U8 +3V3 RST GND NC_33 MISO MOSI SCK SDA8 RF_RFID_RC522
U9 +3V3 RST GND NC_34 MISO MOSI SCK SDA16 RF_RFID_RC522
U11 +3V3 RST GND NC_35 MISO MOSI SCK SDA15 RF_RFID_RC522
U12 +3V3 RST GND NC_36 MISO MOSI SCK SDA14 RF_RFID_RC522
U13 +3V3 RST GND NC_37 MISO MOSI SCK SDA13 RF_RFID_RC522
U14 +3V3 RST GND NC_38 MISO MOSI SCK SDA12 RF_RFID_RC522
U15 +3V3 RST GND NC_39 MISO MOSI SCK SDA11 RF_RFID_RC522
U16 +3V3 RST GND NC_40 MISO MOSI SCK SDA10 RF_RFID_RC522
U17 +3V3 RST GND NC_41 MISO MOSI SCK SDA9 RF_RFID_RC522
U18 +5V GND +3V3 GND Regulator_Linear_NCV4274ADT33RKG
R10 +5V BatLevel Device_R
R11 BatLevel GND Device_R
.end
